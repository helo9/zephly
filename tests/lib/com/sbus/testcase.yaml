## tests/lib/com/sbus/testcase.yaml
```yaml
tests:
  lib.com.sbus.parser:
    platform_allow: native_posix
    tags: communication
```
